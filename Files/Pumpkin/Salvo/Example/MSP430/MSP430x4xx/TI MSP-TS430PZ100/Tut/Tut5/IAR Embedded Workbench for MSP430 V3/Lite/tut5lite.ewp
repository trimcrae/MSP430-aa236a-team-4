# IAR project tut5lite.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xfn.h
  General.OGChipSelectMenu: MSP430FG4619 MSP430FG4619
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.newCCIncludePaths: $PROJ_DIR$; ../..; ../../../../../../../../../Salvo/Inc
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4619.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Project Files/Help Files
    ../: abstract.txt
  group Project Files/Include Files
    ../../: tut5.h
  group Project Files/Source Files
    ../../: tut5.c
    ../: tut5_isr.c
  group Salvo Files/Configuration File
    ./: salvocfg.h
  group Salvo Files/Help Files
    ../../../../../../../../Doc/: newforSalvo4.txt
  group Salvo Files/Libraries
    ../../../../../../../../Lib/IAR430-v3/: salvofiar430x-t.r43
  group Salvo Files/Source Files
    ../../../../../../../../Src/: salvomem.c
