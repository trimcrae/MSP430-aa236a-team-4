# IAR project tut5lite.ewp, settings and files
configuration Debug (MSP430, debug)
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; $PROJ_DIR$; ../..; ../../../../../../../../../SALVO/INC
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F169.xcl
configuration Release (MSP430)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group Project Files/Help Files
    ../../IAR430-v3/: abstract.txt
  group Project Files/Include Files
    ../../: tut5.h
  group Project Files/Source Files
    ../../: tut5.c
    ../../IAR Embedded Workbench for MSP430 V3/: tut5_isr.c
  group Salvo Files/Configuration File
    ./: salvocfg.h
  group Salvo Files/Help Files
    ../../../../../../../../Doc/: newforSalvo4.txt
  group Salvo Files/Libraries
    ../../../../../../../../Lib/IAR430-v2/: salvofiar430-t.r43
  group Salvo Files/Source Files
    ../../../../../../../../Src/: salvomem.c
